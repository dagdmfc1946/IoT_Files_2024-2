options:
  parameters:
    author: hmro2
    generate_options: qt_gui
    id: spectrumsimultaro
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '8'
  states: {}
- name: latitud
  id: variable
  parameters:
    value: '7.136921524265512'
  states: {}
- name: longitud
  id: variable
  parameters:
    value: '-73.12083990526662'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: N
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\INGENIERIA ELECTRONICA\12. Doceavo Semestre\IoT\Practica_9\voz_grabada.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N: N
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import json
      import requests
      from datetime import datetime

      class blk(gr.sync_block):  # Heredando de gr.sync_block
          def __init__(self, url_google_sheet='https://docs.google.com/spreadsheets/d/1ZI1pO5DJjVnh0ph0jH8sRjnLGqXHOz-jBXJ1ZF875JM/edit?usp=sharing', 
      		 latitud=7.136921524265512, longitud=-73.12083990526662, N=8, 
                       finicial=1417000000, fpaso=1421000000, salto=40000):
              gr.sync_block.__init__(self,
                  name="Envia a Google Sheet",
                  in_sig=[(np.float32, N)],  # Recibe un vector de tamaño N
                  out_sig=None)  # No tiene salida
              
      # URL del servicio web de Google Apps Script
              self.url_web_service = 'https://script.google.com/macros/s/AKfycbz7NCKBvRCvhQkuAjcaQUoxhpRQOD_4zOxplrXNP1s2fuiuB-CmPATKADO6ijK__Evm/exec'
              self.url_google_sheet = url_google_sheet
              self.latitud = latitud
              self.longitud = longitud
              self.N = N
              self.finicial = finicial
              self.fpaso = fpaso
              self.salto = salto
              self.contador_entradas = 0  # Contador de entradas
              
              # Contador de ventanas espectrales procesadas
              self.entradas_procesadas = 0

          def registrarDatos(self, data):
              """
              Función que organiza y envía el JSON al servicio web.
              """
              # Convertir los datos del espectro a una cadena separada por comas
              data_str = ','.join([str(d) for d in data])
              
              # Obtener la fecha y hora actuales
              fecha_actual = datetime.now().strftime("%Y-%m-%d %H:%M:%S")
              
              # Crear el objeto JSON para la solicitud
              json_data = {
                  "ordentipo": "crear",
                  "url": self.url_google_sheet,  # URL de la Google Sheet
                  "numeroHoja": 0,
                  "filaencabezados": 1,
                  "columnaId": 1,
                  "datos": json.dumps([  # Envolviendo en json.dumps para convertirlo en una cadena JSON válida
                      fecha_actual,
                      self.latitud,  # Coordenada latitud
                      self.longitud,  # Coordenada longitud
                      "dagd_TestHome",
                      self.N,  # Número de muestras espectrales
                      data_str,  # Datos espectrales
                      self.finicial,  # Frecuencia inicial
                      self.fpaso  # Paso de frecuencia
                  ])
              }
              
              # Enviar el JSON como solicitud POST al servicio web
              try:
                  response = requests.post(self.url_web_service, json=json_data)
                  response.raise_for_status()  # Verificar que no haya errores
                  print(f"Datos enviados exitosamente: {response.text}")
              except requests.exceptions.RequestException as e:
                  print(f"Error enviando datos: {e}")

          def work(self, input_items, output_items):
              """
              Función principal que procesa las entradas y llama a la función de registro.
              """
              # Incrementar el contador de entradas procesadas
              self.entradas_procesadas += len(input_items[0])
              
              # Verificar si se han procesado suficientes entradas (definido por "salto")
              if self.entradas_procesadas >= self.salto:
                  self.entradas_procesadas = 0  # Restablecer el contador
                  
                  # Recibir los datos del espectro (vector de tamaño N)
                  data = input_items[0][0]
                  
                  # Registrar los datos en la Google Sheet
                  self.registrarDatos(data)
              
              return len(input_items[0])  # Indica que se procesaron todas las muestras de entrada
    finicial: 1417e6
    fpaso: '1000'
    latitud: latitud
    longitud: longitud
    salto: '40000'
    url_google_sheet: '''https://docs.google.com/spreadsheets/d/1ZI1pO5DJjVnh0ph0jH8sRjnLGqXHOz-jBXJ1ZF875JM/edit?usp=sharing'''
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(N)
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: N
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [audio_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_mag_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
